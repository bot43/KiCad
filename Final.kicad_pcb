# Repository bot43/KiCad

File README.md:

# KiCad
KiCad Design Files for CMPE 310 lab 5

## KiCad design Final.kicad_pcb

Board: 2 copper layers, 146 parts (0 on the bottom side), 258 nets, no tracks yet.

Parts:
8259INTR1: 8259; DIP-28_W15.24mm
8259Selector1: PAL16L8; DIP-20_W7.62mm
8279Keyboard1: pkd8279; DIP-40_W15.24mm
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28: CP1_Small; CP_Axial_L10.0mm_D4.5mm_P15.00mm_Horizontal
CLK1: 8284; DIP-18_W7.62mm
CLK_Capacitor1: 10uF; CP_Axial_L10.0mm_D4.5mm_P15.00mm_Horizontal
CLK_Resistor1: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
CLK_Switch1: SW_DPST_x2; Push_E-Switch_KS01Q01
CMOS1: 28F010; DIP-32_W7.62mm
CPU1: 8086_Min_Mode; DIP-40_W15.24mm
CPU_ADecode1, CPU_ADecode2, CPU_ADecode3: 74LS373; DIP-20_W7.62mm
CPU_Capacitor1: CP1_Small; CP_Axial_L10.0mm_D4.5mm_P15.00mm_Horizontal
CPU_DDecode1, CPU_DDecode2: 74LS245; DIP-20_W7.62mm
CPU_IO/WR1: 74LS244; DIP-20_W7.62mm
CPU_Resistor1: R_US; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
CPU_Switch1: SW_Push; SW_CW_GPTS203211B
CRYSTAL1: Crystal; Crystal_AT310_D3.0mm_L10.0mm_Vertical
Counter1: 8254; DIP-24_W15.24mm
Counter_Decode1: PAL16L8; DIP-20_W7.62mm
Counter_Header1: Conn_01x06_Female; PinHeader_1x06_P1.00mm_Horizontal
Counter_Resistor1: 10000; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
D1: CPU_Diode; D_5KPW_P7.62mm_Vertical_KathodeUp
D2, D3, D4, D5, D6, D7, D8, D9: LED; LED_D1.8mm_W1.8mm_H2.4mm_Horizontal_O1.27mm_Z4.9mm
DIP_16LA1: PAL16L8; DIP-20_W7.62mm
DIP_LS244: 74LS244; DIP-20_W7.62mm
DIP_Switches1: SW_DIP_x08; SW_CW_GPTS203211B
DSUB1: DSUB-9; DSUB-9_Female_Horizontal_P2.77x2.54mm_EdgePinOffset9.40mm
Display1, Display2, Display3: 74LS374; DIP-20_W7.62mm
Display_Decode1, Display_Decode2: PAL16L8; DIP-20_W7.62mm
HighHighSRAM1: CY7C199; DIP-28_W7.62mm
HighLowSRAM1: CY7C199; DIP-28_W7.62mm
KeyboardSelector1: PAL16L8; DIP-20_W7.62mm
LCD_4x20: LCD4x20; DIP-20_W7.62mm
LCD_16L8: PAL16L8; DIP-20_W7.62mm
LowHighSRAM1: CY7C199; DIP-28_W7.62mm
LowLowSRAM1: CY7C199; DIP-28_W7.62mm
MAX235: max235cpg; DIP-24_W7.62mm
PPI1, PPI2, PPI3: 8255; DIP-40_W15.24mm
PPI_Decoder1: PAL16L8; DIP-20_W7.62mm
PPI_Header1, PPI_Header2, PPI_Header3, PPI_Header4, PPI_Header5, PPI_Header6, PPI_Header7, PPI_Header8, PPI_Header9: Conn_01x08_Female; PinHeader_1x08_P1.00mm_Horizontal
Power_1: Conn_01x02_Female; PinHeader_1x02_P1.00mm_Horizontal
R1: 10000; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R4, R5: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R6, R7, R8, R9, R10, R11, R12, R13: 330; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R14, R15, R16, R17, R18, R19, R20, R21: R_Small_US; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
Resistor10K1: Resistor; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
SIXTEENL8: PAL16L8; DIP-20_W7.62mm
SRAMSelector1: PAL16L8; DIP-20_W7.62mm
SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25: SW_Push; SW_PUSH-12mm
Seven_Seg1, Seven_Seg2: MAN71A
U1, U19, U20, U21: 74AHC1G08; DIP-5-6_W7.62mm
U9: 74LS138; DIP-16_W7.62mm
U12, U17, U18: 74LS04; DIP-14_W7.62mm
U41: 28F010; DIP-32_W7.62mm
UART1: 16550; DIP-40_W15.24mm

Connections:
+5V: 8279Keyboard1.40, Counter_Resistor1.1, KeyboardSelector1.20, R1.1
+12V: CMOS1.1, U41.1
/8086/AD0: CPU1.16, CPU_ADecode1.3, CPU_DDecode1.2
/8086/AD1: CPU1.15, CPU_ADecode1.4, CPU_DDecode1.3
/8086/AD2: CPU1.14, CPU_ADecode1.7, CPU_DDecode1.4
/8086/AD3: CPU1.13, CPU_ADecode1.8, CPU_DDecode1.5
/8086/AD4: CPU1.12, CPU_ADecode1.13, CPU_DDecode1.6
/8086/AD5: CPU1.11, CPU_ADecode1.14, CPU_DDecode1.7
/8086/AD6: CPU1.10, CPU_ADecode1.17, CPU_DDecode1.8
/8086/AD7: CPU1.9, CPU_ADecode1.18, CPU_DDecode1.9
/8086/AD8: CPU1.8, CPU_ADecode2.3, CPU_DDecode2.2
/8086/AD9: CPU1.7, CPU_ADecode2.4, CPU_DDecode2.3
/8086/AD10: CPU1.6, CPU_ADecode2.7, CPU_DDecode2.4
/8086/AD11: CPU1.5, CPU_ADecode2.8, CPU_DDecode2.5
/8086/AD12: CPU1.4, CPU_ADecode2.13, CPU_DDecode2.6
/8086/AD13: CPU1.3, CPU_ADecode2.14, CPU_DDecode2.7
/8086/AD14: CPU1.2, CPU_ADecode2.17, CPU_DDecode2.8
/8086/AD15: CPU1.39, CPU_ADecode2.18, CPU_DDecode2.9
/8086/ALE: CPU1.25, CPU_ADecode1.11, CPU_ADecode2.11, CPU_ADecode3.11
/8086/DT~R: CPU1.27, CPU_DDecode1.1, CPU_DDecode2.1
/8086/IO: CPU1.28, CPU_IO/WR1.2
/8086/READY: CLK1.5, CPU1.22
/8086/Read: CPU1.32, CPU_IO/WR1.6
/8086/S3: CPU1.38, CPU_ADecode3.3
/8086/S4: CPU1.37, CPU_ADecode3.4
/8086/S5: CPU1.36, CPU_ADecode3.7
/8086/S6: CPU1.35, CPU_ADecode3.8
/8086/Write: CPU1.29, CPU_IO/WR1.4
/8086/~DEN: CPU1.26, CPU_DDecode1.19, CPU_DDecode2.19
/8255/P0: PPI1.4, PPI_Header1.1
/8255/P1: PPI1.3, PPI_Header1.2
/8255/P2: PPI1.2, PPI_Header1.3
/8255/P3: PPI1.1, PPI_Header1.4
/8255/P4: PPI1.40, PPI_Header1.5
/8255/P5: PPI1.39, PPI_Header1.6
/8255/P6: PPI1.38, PPI_Header1.7
/8255/P7: PPI1.37, PPI_Header1.8
/8255/P8: PPI1.18, PPI_Header2.1
/8255/P9: PPI1.19, PPI_Header2.2
/8255/P10: PPI1.20, PPI_Header2.3
/8255/P11: PPI1.21, PPI_Header2.4
/8255/P12: PPI1.22, PPI_Header2.5
/8255/P13: PPI1.23, PPI_Header2.6
/8255/P14: PPI1.24, PPI_Header2.7
/8255/P15: PPI1.25, PPI_Header2.8
/8255/P16: PPI1.14, PPI_Header3.1
/8255/P17: PPI1.15, PPI_Header3.2
/8255/P18: PPI1.16, PPI_Header3.3
/8255/P19: PPI1.17, PPI_Header3.4
/8255/P20: PPI1.13, PPI_Header3.5
/8255/P21: PPI1.12, PPI_Header3.6
/8255/P22: PPI1.11, PPI_Header3.7
/8255/P23: PPI1.10, PPI_Header3.8
/8255/P24: PPI2.4, PPI_Header4.1
/8255/P25: PPI2.3, PPI_Header4.2
/8255/P26: PPI2.2, PPI_Header4.3
/8255/P27: PPI2.1, PPI_Header4.4
/8255/P28: PPI2.40, PPI_Header4.5
/8255/P29: PPI2.39, PPI_Header4.6
/8255/P30: PPI2.38, PPI_Header4.7
/8255/P31: PPI2.37, PPI_Header4.8
/8255/P32: PPI2.18, PPI_Header5.1
/8255/P33: PPI2.19, PPI_Header5.2
/8255/P34: PPI2.20, PPI_Header5.3
/8255/P35: PPI2.21, PPI_Header5.4
/8255/P36: PPI2.22, PPI_Header5.5
/8255/P37: PPI2.23, PPI_Header5.6
/8255/P38: PPI2.24, PPI_Header5.7
/8255/P39: PPI2.25, PPI_Header5.8
/8255/P40: PPI2.14, PPI_Header6.1
/8255/P41: PPI2.15, PPI_Header6.2
/8255/P42: PPI2.16, PPI_Header6.3
/8255/P43: PPI2.17, PPI_Header6.4
/8255/P44: PPI2.13, PPI_Header6.5
/8255/P45: PPI2.12, PPI_Header6.6
/8255/P46: PPI2.11, PPI_Header6.7
/8255/P47: PPI2.10, PPI_Header6.8
/8255/P48: PPI3.4, PPI_Header7.1
/8255/P49: PPI3.3, PPI_Header7.2
/8255/P50: PPI3.2, PPI_Header7.3
/8255/P51: PPI3.1, PPI_Header7.4
/8255/P52: PPI3.40, PPI_Header7.5
/8255/P53: PPI3.39, PPI_Header7.6
/8255/P54: PPI3.38, PPI_Header7.7
/8255/P55: PPI3.37, PPI_Header7.8
/8255/P56: PPI3.18, PPI_Header8.1
/8255/P57: PPI3.19, PPI_Header8.2
/8255/P58: PPI3.20, PPI_Header8.3
/8255/P59: PPI3.21, PPI_Header8.4
/8255/P60: PPI3.22, PPI_Header8.5
/8255/P61: PPI3.23, PPI_Header8.6
/8255/P62: PPI3.24, PPI_Header8.7
/8255/P63: PPI3.25, PPI_Header8.8
/8255/P64: PPI3.14, PPI_Header9.1
/8255/P65: PPI3.15, PPI_Header9.2
/8255/P66: PPI3.16, PPI_Header9.3
/8255/P67: PPI3.17, PPI_Header9.4
/8255/P68: PPI3.13, PPI_Header9.5
/8255/P69: PPI3.12, PPI_Header9.6
/8255/P70: PPI3.11, PPI_Header9.7
/8255/P71: PPI3.10, PPI_Header9.8
/8259/IR0: 8259INTR1.18, SW3.1
/8279/CNTRL: 8279Keyboard1.37, SW25.1
/8279/CS: 8279Keyboard1.22, KeyboardSelector1.19
/8279/Col0: 8279Keyboard1.38, SW4.2, SW5.2, SW6.2, SW7.2
/8279/Col1: 8279Keyboard1.39, SW8.2, SW9.2, SW10.2, SW11.2
/8279/Col2: 8279Keyboard1.1, SW12.2, SW13.2, SW14.2, SW15.2
/8279/Col3: 8279Keyboard1.2, SW16.2, SW17.2, SW18.2, SW19.2
/8279/Col4: 8279Keyboard1.5, SW20.2, SW21.2, SW22.2, SW23.2
/8279/Row0: 8279Keyboard1.32, SW4.1, SW8.1, SW12.1, SW16.1, SW20.1
/8279/Row1: 8279Keyboard1.33, SW5.1, SW9.1, SW13.1, SW17.1, SW21.1
/8279/Row2: 8279Keyboard1.34, SW6.1, SW10.1, SW14.1, SW18.1, SW22.1
/8279/Row3: 8279Keyboard1.35, SW7.1, SW11.1, SW15.1, SW19.1, SW23.1
/8279/Shift: 8279Keyboard1.36, SW24.1
/16550/CTS: DSUB1.8, MAX235.18
/16550/DCD: MAX235.9, UART1.38
/16550/DCD9: DSUB1.1, MAX235.10
/16550/DSR: MAX235.23, UART1.37
/16550/DSR9: DSUB1.6, MAX235.24
/16550/DTR: MAX235.7, UART1.33
/16550/DTR9: DSUB1.4, MAX235.4
/16550/RI: MAX235.14, UART1.39
/16550/RI9: DSUB1.9, MAX235.13
/16550/RTS: MAX235.15, UART1.32
/16550/RTS9: DSUB1.7, MAX235.2
/16550/RXD: DSUB1.2, MAX235.5
/16550/SIN: MAX235.6, UART1.10
/16550/SOUT: MAX235.8, UART1.11
/16550/TXD: DSUB1.3, MAX235.3
/16550/~CTS: MAX235.17, UART1.36
/16550_INTR: 8259INTR1.21, UART1.30
/A0: CMOS1.12, CPU_ADecode1.2, Counter_Decode1.2, DIP_16LA1.1, Display_Decode2.11, HighHighSRAM1.21, HighLowSRAM1.21, LCD_16L8.1, LowHighSRAM1.21, LowLowSRAM1.21, PPI_Decoder1.1, SIXTEENL8.1, SRAMSelector1.16, U41.12, UART1.28
/A1: 8259INTR1.27, 8279Keyboard1.21, CMOS1.11, CPU_ADecode1.5, Counter1.19, DIP_16LA1.2, Display_Decode2.9, HighHighSRAM1.23, HighLowSRAM1.23, LCD_16L8.2, LowHighSRAM1.23, LowLowSRAM1.23, PPI1.9, PPI2.9, PPI3.9, SIXTEENL8.2, SRAMSelector1.1, U41.11, UART1.27
/A2: 8259Selector1.1, CMOS1.10, CPU_ADecode1.6, Counter1.20, DIP_16LA1.3, Display_Decode2.8, HighHighSRAM1.24, HighLowSRAM1.24, KeyboardSelector1.1, LCD_16L8.3, LowHighSRAM1.24, LowLowSRAM1.24, PPI1.8, PPI2.8, PPI3.8, SIXTEENL8.3, SRAMSelector1.2, U41.10, UART1.26
/A3: 8259Selector1.2, CMOS1.9, CPU_ADecode1.9, Counter_Decode1.3, DIP_16LA1.4, Display_Decode2.7, HighHighSRAM1.25, HighLowSRAM1.25, KeyboardSelector1.2, LCD_16L8.4, LowHighSRAM1.25, LowLowSRAM1.25, PPI_Decoder1.2, SIXTEENL8.4, SRAMSelector1.3, U41.9
/A4: 8259Selector1.3, CMOS1.8, CPU_ADecode1.12, Counter_Decode1.4, DIP_16LA1.5, Display_Decode2.6, HighHighSRAM1.26, HighLowSRAM1.26, KeyboardSelector1.3, LCD_16L8.5, LowHighSRAM1.26, LowLowSRAM1.26, PPI_Decoder1.3, SIXTEENL8.5, SRAMSelector1.4, U41.8
/A5: 8259Selector1.4, CMOS1.7, CPU_ADecode1.15, Counter_Decode1.5, DIP_16LA1.6, Display_Decode2.5, HighHighSRAM1.1, HighLowSRAM1.1, KeyboardSelector1.4, LCD_16L8.6, LowHighSRAM1.1, LowLowSRAM1.1, PPI_Decoder1.4, SIXTEENL8.6, SRAMSelector1.5, U41.7
/A6: 8259Selector1.5, CMOS1.6, CPU_ADecode1.16, Counter_Decode1.6, DIP_16LA1.7, Display_Decode2.4, HighHighSRAM1.2, HighLowSRAM1.2, KeyboardSelector1.5, LCD_16L8.7, LowHighSRAM1.2, LowLowSRAM1.2, PPI_Decoder1.5, SIXTEENL8.7, SRAMSelector1.6, U41.6
/A7: 8259Selector1.6, CMOS1.5, CPU_ADecode1.19, Counter_Decode1.7, DIP_16LA1.8, Display_Decode2.3, HighHighSRAM1.3, HighLowSRAM1.3, KeyboardSelector1.6, LCD_16L8.8, LowHighSRAM1.3, LowLowSRAM1.3, PPI_Decoder1.6, SIXTEENL8.8, SRAMSelector1.7, U41.5
/A8: 8259Selector1.7, CMOS1.27, CPU_ADecode2.2, Counter_Decode1.8, DIP_16LA1.9, Display_Decode1.11, HighHighSRAM1.4, HighLowSRAM1.4, KeyboardSelector1.7, LCD_16L8.9, LowHighSRAM1.4, LowLowSRAM1.4, PPI_Decoder1.8, SIXTEENL8.9, SRAMSelector1.8, U41.27
/A9: 8259Selector1.8, CMOS1.26, CPU_ADecode2.5, Counter_Decode1.9, DIP_16LA1.11, Display_Decode1.9, HighHighSRAM1.5, HighLowSRAM1.5, KeyboardSelector1.8, LCD_16L8.11, LowHighSRAM1.5, LowLowSRAM1.5, PPI_Decoder1.7, SIXTEENL8.11, SRAMSelector1.9, U41.26
/A10: 8259Selector1.9, CMOS1.23, CPU_ADecode2.6, Counter_Decode1.11, Display_Decode1.8, HighHighSRAM1.6, HighLowSRAM1.6, KeyboardSelector1.9, LCD_16L8.13, LowHighSRAM1.6, LowLowSRAM1.6, PPI_Decoder1.9, SRAMSelector1.17, U41.23
/A11: 8259Selector1.11, CMOS1.25, CPU_ADecode2.9, Counter_Decode1.13, DIP_16LA1.18, Display_Decode1.7, HighHighSRAM1.7, HighLowSRAM1.7, KeyboardSelector1.11, LCD_16L8.14, LowHighSRAM1.7, LowLowSRAM1.7, PPI_Decoder1.11, SIXTEENL8.18, U41.25
/A12: 8259Selector1.14, CMOS1.4, CPU_ADecode2.12, Counter_Decode1.14, DIP_16LA1.17, Display_Decode1.6, HighHighSRAM1.8, HighLowSRAM1.8, KeyboardSelector1.14, LCD_16L8.15, LowHighSRAM1.8, LowLowSRAM1.8, PPI_Decoder1.13, SIXTEENL8.17, U41.4
/A13: 8259Selector1.15, CMOS1.28, CPU_ADecode2.15, Counter_Decode1.15, DIP_16LA1.16, Display_Decode1.5, HighHighSRAM1.9, HighLowSRAM1.9, KeyboardSelector1.15, LCD_16L8.16, LowHighSRAM1.9, LowLowSRAM1.9, PPI_Decoder1.14, SIXTEENL8.16, U41.28
/A14: 8259Selector1.16, CMOS1.29, CPU_ADecode2.16, Counter_Decode1.16, DIP_16LA1.15, Display_Decode1.4, HighHighSRAM1.10, HighLowSRAM1.10, KeyboardSelector1.16, LCD_16L8.17, LowHighSRAM1.10, LowLowSRAM1.10, PPI_Decoder1.15, SIXTEENL8.15, U41.29
/A15: 8259Selector1.17, CMOS1.3, CPU_ADecode2.19, Counter_Decode1.17, DIP_16LA1.14, Display_Decode1.3, KeyboardSelector1.17, LCD_16L8.18, PPI_Decoder1.16, SIXTEENL8.14, U41.3
/A16: CMOS1.2, CPU_ADecode3.2, U41.2
/A17: CPU_ADecode3.5, U9.1
/A18: CPU_ADecode3.6, U9.2
/A19: CPU_ADecode3.9, U9.3
/CLK: CLK1.8, CPU1.19, Counter1.15
/CMOS Flash/CMOSHierarchal1/CS: CMOS1.22, U12.2
/CMOS Flash/CMOSHierarchal/CS: U9.15, U12.1, U41.22
/CNTR2: 8259INTR1.19, Counter1.13
/D0: 8259INTR1.11, 8279Keyboard1.12, CMOS1.13, CPU_DDecode1.18, Counter1.8, DIP_LS244.18, Display2.18, Display3.18, LCD_4x20.7, LowHighSRAM1.11, LowLowSRAM1.11, PPI1.34, PPI2.34, PPI3.34, U41.13, UART1.1
/D1: 8259INTR1.10, 8279Keyboard1.13, CMOS1.14, CPU_DDecode1.17, Counter1.7, DIP_LS244.16, Display2.17, Display3.17, LCD_4x20.8, LowHighSRAM1.12, LowLowSRAM1.12, PPI1.33, PPI2.33, PPI3.33, U41.14, UART1.2
/D2: 8259INTR1.9, 8279Keyboard1.14, CMOS1.15, CPU_DDecode1.16, Counter1.6, DIP_LS244.14, Display2.14, Display3.14, LCD_4x20.9, LowHighSRAM1.13, LowLowSRAM1.13, PPI1.32, PPI2.32, PPI3.32, U41.15, UART1.3
/D3: 8259INTR1.8, 8279Keyboard1.15, CMOS1.17, CPU_DDecode1.15, Counter1.5, DIP_LS244.12, Display2.13, Display3.13, LCD_4x20.10, LowHighSRAM1.15, LowLowSRAM1.15, PPI1.31, PPI2.31, PPI3.31, U41.17, UART1.4
/D4: 8259INTR1.7, 8279Keyboard1.16, CMOS1.18, CPU_DDecode1.14, Counter1.4, DIP_LS244.9, Display2.8, Display3.8, LCD_4x20.11, LowHighSRAM1.16, LowLowSRAM1.16, PPI1.30, PPI2.30, PPI3.30, U41.18, UART1.5
/D5: 8259INTR1.6, 8279Keyboard1.17, CMOS1.19, CPU_DDecode1.13, Counter1.3, DIP_LS244.7, Display2.7, Display3.7, LCD_4x20.12, LowHighSRAM1.17, LowLowSRAM1.17, PPI1.29, PPI2.29, PPI3.29, U41.19, UART1.6
/D6: 8259INTR1.5, 8279Keyboard1.18, CMOS1.20, CPU_DDecode1.12, Counter1.2, DIP_LS244.5, Display2.4, Display3.4, LCD_4x20.13, LowHighSRAM1.18, LowLowSRAM1.18, PPI1.28, PPI2.28, PPI3.28, U41.20, UART1.7
/D7: 8259INTR1.4, 8279Keyboard1.19, CMOS1.21, CPU_DDecode1.11, Counter1.1, DIP_LS244.3, Display2.3, Display3.3, LCD_4x20.14, LowHighSRAM1.19, LowLowSRAM1.19, PPI1.27, PPI2.27, PPI3.27, U41.21, UART1.8
/D8: CPU_DDecode2.18, Display1.18, HighHighSRAM1.11, HighLowSRAM1.11
/D9: CPU_DDecode2.17, Display1.17, HighHighSRAM1.12, HighLowSRAM1.12
/D10: CPU_DDecode2.16, Display1.14, HighHighSRAM1.13, HighLowSRAM1.13
/D11: CPU_DDecode2.15, Display1.13, HighHighSRAM1.15, HighLowSRAM1.15
/D12: CPU_DDecode2.14, Display1.8, HighHighSRAM1.16, HighLowSRAM1.16
/D13: CPU_DDecode2.13, Display1.7, HighHighSRAM1.17, HighLowSRAM1.17
/D14: CPU_DDecode2.12, Display1.4, HighHighSRAM1.18, HighLowSRAM1.18
/D15: CPU_DDecode2.11, Display1.3, HighHighSRAM1.19, HighLowSRAM1.19
/INTR: 8259INTR1.17, CPU1.18
/IRQ: 8259INTR1.20, 8279Keyboard1.4
/M~IO: 8259Selector1.13, CPU_IO/WR1.18, Counter_Decode1.1, KeyboardSelector1.13, LCD_4x20.4, PPI_Decoder1.12
/PCLK: 8279Keyboard1.3, CLK1.2, UART1.16
/RESET: 8279Keyboard1.9, CLK1.10, CPU1.21, PPI1.35, PPI2.35, PPI3.35, UART1.35
/SRAM/CE00: LowLowSRAM1.20, U1.4
/SRAM/CE01: HighLowSRAM1.20, U21.4
/SRAM/CE10: LowHighSRAM1.20, U20.4
/SRAM/CE11: HighHighSRAM1.20, U19.4
/~BHE~S7: CPU1.34, SRAMSelector1.11
/~INTA: 8259INTR1.26, CPU1.24
/~RD: 8259INTR1.3, 8279Keyboard1.10, CMOS1.24, CPU_IO/WR1.14, Counter1.22, HighHighSRAM1.22, HighLowSRAM1.22, LowHighSRAM1.22, LowLowSRAM1.22, PPI1.5, PPI2.5, PPI3.5, U41.24, UART1.21
/~WR: 8259INTR1.2, 8279Keyboard1.11, CMOS1.31, CPU_IO/WR1.16, Counter1.23, Display_Decode1.2, Display_Decode2.2, HighHighSRAM1.27, HighLowSRAM1.27, LCD_4x20.5, LowHighSRAM1.27, LowLowSRAM1.27, PPI1.36, PPI2.36, PPI3.36, U41.31, UART1.18
GND: 8259INTR1.14, 8259Selector1.10, 8279Keyboard1.20, CLK1.1, CLK1.9, CLK1.13, CLK_Capacitor1.2, CLK_Switch1.2, CMOS1.16, CPU1.1, CPU1.20, CPU_ADecode1.1, CPU_ADecode1.10, CPU_ADecode2.1, CPU_ADecode2.10, CPU_ADecode3.1, CPU_ADecode3.10, CPU_Capacitor1.2, CPU_DDecode1.10, CPU_DDecode2.10, CPU_IO/WR1.1, CPU_IO/WR1.10, CPU_IO/WR1.19, CPU_Switch1.1, Counter1.12, Counter_Decode1.10, DIP_16LA1.10, DIP_LS244.1, DIP_LS244.10, DSUB1.5, Display1.1, Display1.10, Display2.1, Display2.10, Display3.1, Display3.10, Display_Decode1.10, Display_Decode2.10, HighHighSRAM1.14, HighLowSRAM1.14, KeyboardSelector1.10, LCD_4x20.1, LCD_4x20.3, LCD_4x20.16, LCD_16L8.10, LowHighSRAM1.14, LowLowSRAM1.14, MAX235.11, MAX235.20, MAX235.21, PPI1.7, PPI2.7, PPI3.7, PPI_Decoder1.10, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, SIXTEENL8.10, SRAMSelector1.10, SW3.2, SW24.2, SW25.2, U1.3, U9.4, U9.8, U19.3, U20.3, U21.3, U41.16, UART1.19, UART1.20, UART1.22, UART1.25
unnamed: 8259INTR1.1, 8259Selector1.19
unnamed: 8259INTR1.16, R1.2
unnamed: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, Power_1.1
unnamed: CLK1.11, CLK_Capacitor1.1, CLK_Resistor1.2, CLK_Switch1.1
unnamed: CLK1.16, CRYSTAL1.1
unnamed: CLK1.17, CRYSTAL1.2
unnamed: CPU1.17, CPU_Resistor1.1, D1.1
unnamed: Counter1.9, Counter_Header1.1
unnamed: Counter1.10, Counter_Header1.3
unnamed: Counter1.11, Counter_Header1.2
unnamed: Counter1.14, Counter_Resistor1.2
unnamed: Counter1.16, Counter_Header1.5
unnamed: Counter1.17, Counter_Header1.6
unnamed: Counter1.18, Counter_Header1.4
unnamed: Counter1.21, Counter_Decode1.18, Counter_Decode1.19
unnamed: D2.1, Display3.12
unnamed: D2.2, R6.2
unnamed: D3.1, Display3.2
unnamed: D3.2, R7.2
unnamed: D4.1, Display3.6
unnamed: D4.2, R8.2
unnamed: D5.1, Display3.16
unnamed: D5.2, R9.2
unnamed: D6.1, Display3.9
unnamed: D6.2, R10.2
unnamed: D7.1, Display3.15
unnamed: D7.2, R11.2
unnamed: D8.1, Display3.19
unnamed: D8.2, R12.2
unnamed: D9.1, Display3.5
unnamed: D9.2, R13.2
unnamed: DIP_16LA1.19, DIP_LS244.19
unnamed: DIP_LS244.2, R21.1
unnamed: DIP_LS244.4, R20.1
unnamed: DIP_LS244.6, R19.1
unnamed: DIP_LS244.8, R18.1
unnamed: DIP_LS244.11, R17.1
unnamed: DIP_LS244.13, R16.1
unnamed: DIP_LS244.15, DIP_Switches1.2, R15.1
unnamed: DIP_LS244.17, DIP_Switches1.1, R14.1
unnamed: Display1.2, Seven_Seg1.1
unnamed: Display1.5, Seven_Seg1.13
unnamed: Display1.6, Seven_Seg1.10
unnamed: Display1.9, Seven_Seg1.8
unnamed: Display1.11, Display_Decode1.19
unnamed: Display1.12, Seven_Seg1.7
unnamed: Display1.15, Seven_Seg1.2
unnamed: Display1.16, Seven_Seg1.11
unnamed: Display1.19, Seven_Seg1.9
unnamed: Display2.2, Seven_Seg2.1
unnamed: Display2.5, Seven_Seg2.13
unnamed: Display2.6, Seven_Seg2.10
unnamed: Display2.9, Seven_Seg2.8
unnamed: Display2.11, Display_Decode2.19
unnamed: Display2.12, Seven_Seg2.7
unnamed: Display2.15, Seven_Seg2.2
unnamed: Display2.16, Seven_Seg2.11
unnamed: Display2.19, Seven_Seg2.9
unnamed: Display3.11, Display_Decode2.18
unnamed: LCD_4x20.6, LCD_16L8.19
unnamed: PPI1.6, PPI_Decoder1.19
unnamed: PPI2.6, PPI_Decoder1.18
unnamed: PPI3.6, PPI_Decoder1.17
unnamed: R4.2, Seven_Seg1.14
unnamed: R5.2, Seven_Seg2.14
unnamed: Resistor10K1.2, UART1.12, UART1.13
unnamed: SIXTEENL8.19, UART1.14
unnamed: SRAMSelector1.18, U18.1, U19.2, U21.2
unnamed: SRAMSelector1.19, U17.1, U19.1, U20.1
unnamed: U1.1, U18.2, U20.2
unnamed: U1.2, U17.2, U21.1
unnamed: UART1.9, UART1.15
VCC: 8259INTR1.28, 8259Selector1.20, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, CLK1.18, CLK_Resistor1.1, CMOS1.32, CPU1.33, CPU1.40, CPU_ADecode1.20, CPU_ADecode2.20, CPU_ADecode3.20, CPU_Capacitor1.1, CPU_DDecode1.20, CPU_DDecode2.20, CPU_IO/WR1.20, CPU_Resistor1.2, CPU_Switch1.2, Counter1.24, Counter_Decode1.20, D1.2, DIP_16LA1.20, DIP_LS244.20, Display1.20, Display2.20, Display3.20, Display_Decode1.20, Display_Decode2.20, HighHighSRAM1.28, HighLowSRAM1.28, LCD_4x20.15, LCD_16L8.20, LowHighSRAM1.28, LowLowSRAM1.28, MAX235.12, PPI1.26, PPI2.26, PPI3.26, PPI_Decoder1.20, Power_1.2, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, Resistor10K1.1, SIXTEENL8.20, SRAMSelector1.20, U9.5, U9.6, U9.16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

## Commit log

2021-04-13 Added KiCad FIles with one resistor
2021-04-13 parts file
